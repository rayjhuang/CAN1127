# Keil uVision project hwi2c_fw.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8052AH Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(12000000)
  output: hwi2c_fw +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: hwi2c_fw.c
