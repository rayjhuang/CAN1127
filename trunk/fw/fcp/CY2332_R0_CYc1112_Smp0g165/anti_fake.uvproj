# Keil uVision project anti_fake.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cy2332r0 +hex
  AfterMake: .\Tools\make.bat 8192
  c flags: Optimize=8
  c include: .\Includes
  group Tools
    ./Tools/: make_8K.bat make_16K512.bat make.bat Hex2Bin
  group Header
    ./Includes/: config.h global.h scp.h adapter_antifake.h
  group New Group
    ./Source/: adapter_antifake.c
target 10K (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cy2332r0 +hex
  AfterMake: .\Tools\make.bat 10240
  c flags: Optimize=8
  c include: .\Includes
target 16K (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cy2332r0 +hex
  AfterMake: .\Tools\make.bat 16384
  c flags: Optimize=8
  c include: .\Includes
target lib (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: AntiFake +hex (library)
  c flags: Optimize=8
  c include: .\Includes
