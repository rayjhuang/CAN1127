# Keil uVision project cy2332r0.uvproj, settings and files
target Target 1 (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cy2332r0 +hex
  AfterMake: .\Tools\make.bat 8192
  c flags: Optimize=8
  c include: .\Includes
  group Tools
    ./Tools/: make_8K.bat make_16K512.bat make.bat Hex2Bin
  group Header
    ./Includes/: can1110_hal.h can1110_reg.h can1112_hal.h can1112_reg.h config.h global.h intro1110.h power.h dynpdp.h twoport.h kpos.h scp.h digitalCC.h appledex.h cca1.h bbi2c.h adapter_antifake.h vooc.h
  group Source Group 1
    ./: rev.txt
    ./Source/: main.c otp.c protect.c qc.c typec.c power.c updpm.c updpe.c updprl.c updphy.c dynpdp.c twoport.c kpos.c digitalCC.c appledex.c cca1.c bbi2c.c vooc.c scp_phy.c scp_prl.c
    ./Objects/: AntiFake.LIB STARTUP.A51
target 10K (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cy2332r0 +hex
  AfterMake: .\Tools\make.bat 10240
  c flags: Optimize=8
  c include: .\Includes
target 16K (MCS-51)
  device: R8051XC2 CAST, Inc.
  cpu: IRAM(0-0xFF) CLOCK(24000000)  MOD517DP MDU_R515
  output: cy2332r0 +hex
  AfterMake: .\Tools\make.bat 16384
  c flags: Optimize=8
  c include: .\Includes
